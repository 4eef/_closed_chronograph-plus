# IAR project Backup of Chrono-Terminal-V1.0.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F042F6 ST STM32F042F6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\libfixmath\inc; ..\app\inc; ..\debugFiles\inc; ..\drivers\inc; ..\USB\CDC\Inc; ..\USB\Core\Inc; ..\FreeRTOS\inc; ..\hal_driver\inc; ..\hal_driver\inc\Legacy; ..\task\inc; ..\cm0\Device\ST\STM32F0xx\Include; ..\cm0\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Chrono-Terminal-V1.0.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f042x6.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../app/src/: adc.c battery.c buttons.c delay.c filter.c IR.c lis3.c main.c MicroMenu.c power.c ssdFonts.c ssdGraph.c sync.c system.c ug2864.c
  group CMSIS
    ../cm0/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f042x6.s
    ../cm0/Device/ST/STM32F0xx/Include/: stm32f042x6.h
    ../cm0/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group drivers
    ../drivers/src/: clock.c gpio.c i2c.c
  group libfixmath
    ../libfixmath/src/: fix16.c fix16_exp.c fix16_sqrt.c fix16_trig.c fract32.c uint32.c
